# Keil uVision project lcd_test.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: lcd_test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\lcd_test;..\..\lcd;.\库函数
  group Source Group 1
    ./: STARTUP.A51 lcd_test.c delay.c
    ../: HT1621B_Drive.c LCD.c
    ./库函数/: ADC.c EEPROM.c Exti.c GPIO.c timer.c
