# Keil uVision project Elec_Actuator_V4.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: yuan_firmware +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\STC15_LIB;..\User\source\control;..\User\source\current_output;..\User\source\data_input;..\User\source\data_save;..\User\source\include;..\User\source\ir;..\User\source\lcd;..\User\source\motor;..\User\source\phase_detect;..\User\source\ringbuffer;..\User\source\uart;..\User\source\driver;..\User\source\lowpassfilter;..\User\source
  group User
    ./: STARTUP.A51
    ../User/source/: main.c
  group STC_LIB
    ../STC15_LIB/: delay.c EEPROM.c Exti.c GPIO.c timer.c ADC.c PCA.c USART.C
  group LCD
    ../User/source/lcd/: HT1621B_Drive.c LCD.c
  group MOTOR
    ../User/source/motor/: motor.c motor_protect.c
  group UART
    ../User/source/uart/: uart_debug.c
  group DATA_SAVE
    ../User/source/data_save/: data_save.c
  group DATA_INPUT
    ../User/source/data_input/: data_input.c mlx90316.c spi.c
  group CURRENT_OUTPUT
    ../User/source/current_output/: current_output.c
  group PHASE_DETECT
    ../User/source/phase_detect/: phase_detect.c
  group CONTROL
    ../User/source/control/: control_new.c distant_analog.c distant_digital.c local.c mode_detect.c
  group IR
    ../User/source/ir/: ir.c
    ../User/source/ringbuffer/: ringbuffer.c
  group Driver
    ../User/source/driver/: butterworth_filter.c
